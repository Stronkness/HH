<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Lab1_1.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\Lab1_2\Lab1_2.ewp</path>
  </project>
  <batchBuild/>
</workspace>


